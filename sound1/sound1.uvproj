# Keil uVision project sound1.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC11F60XE STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: sound1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 LDChip.c main.c Reg_RW.c usart.c
